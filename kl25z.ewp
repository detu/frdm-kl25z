# IAR project kl25z.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 NXP MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL25Z128VLK4; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; FRDM_KL25Z; FREEDOM
  ICCARM.CCIncludePath2: C:\Users\suwareka\Documents\frdm-kl25z\devices\MKL25Z4; C:\Users\suwareka\Documents\frdm-kl25z\CMSIS\Include; C:\Users\suwareka\Documents\frdm-kl25z\devices\MKL25Z4\cmsis_drivers; C:\Users\suwareka\Documents\frdm-kl25z\devices\MKL25Z4\drivers; C:\Users\suwareka\Documents\frdm-kl25z\devices\MKL25Z4\iar; C:\Users\suwareka\Documents\frdm-kl25z\devices\MKL25Z4\utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: kl25z.out
  ILINK.IlinkIcfFile: C:\Users\suwareka\Documents\frdm-kl25z\MKL25Z128xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group board
    ./: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group drivers
    devices/MKL25Z4/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_lpsci.c fsl_lpsci.h fsl_port.h fsl_sim.c fsl_sim.h fsl_uart.c fsl_uart.h
  group source
    ./: main.c
  group startup
    devices/MKL25Z4/iar/: startup_MKL25Z4.s
    devices/MKL25Z4/: system_MKL25Z4.c system_MKL25Z4.h
  group utilities
    devices/MKL25Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
